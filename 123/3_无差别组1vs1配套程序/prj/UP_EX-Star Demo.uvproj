# Keil uVision project UP_EX-Star Demo.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UP_ADC +hex
  AfterMake: C:\ChengXu\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  ../List/UP_ADC.bin  ../List/UP_ADC.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\src\STM32Lib;..\src\UpLib\STM32Lib;..\src\UpLib;..\src
  asm include: ..\src\STM32Lib
  library: MicroLIB
  memory RVCT4: ROM 0x800b000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Usr
    ../src/: main.c
  group FwLib
    ../src/UpLib/STM32Lib/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c stm32f10x_exti.c
  group StartUp
    ../src/UpLib/STM32Lib/StartUp/: startup_stm32f10x_hd.s cortexm3_macro.s
  group UpLib
    ../src/UpLib/: UP_System.c UP_Globle.c UP_ADC.c UP_Key.c UP_LCD.c UP_UART.c UP_it.c UP_Exti.c UP_Timer.c UP_NVIC.c UP_PWM.c UP_Bluetooth.c UP_CDS5500.c UP_Zigbee.c UP_USR232.c UP_IOout.c UP_VGA.c UP_RFID.c UP_MP3.c UP_Variable.c UP_UART_Parse.c UP_Woody_VoicePlaying.c UP_Woody_SpeechRecognition.c UP_Woody_ImageRecognition.c
